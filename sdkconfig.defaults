## sdkconfig.defaults
```kconfig
CONFIG_LOG_COLORS=y
CONFIG_BOOTLOADER_LOG_COLORS=y
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
CONFIG_ESP_CONSOLE_UART_BAUDRATE=115200
```
